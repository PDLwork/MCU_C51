#include <REGX52.H>
#include "UserDef.H"
#include "Delay.H"
#include "74HC595.H"
#include "Timer.H"
	
INT8U LED_duan1[] = {	0xFF,0xFF,0xF0,0xF7,0xF6,0xD5,0xE7,0xF7,0xF7,0xE7,0xD5,0xF6,0xF7,0xF0,0xFF,0xFF,
						0xFF,0xFF,0x07,0xF7,0xF3,0xB7,0xD7,0xB7,0xB7,0xD7,0xB7,0xF3,0xF7,0x07,0xFF,0xFF
					};
INT8U LED_duan2[] = {	0xFF,0xFF,0xF0,0xF7,0xF6,0xD5,0xE7,0xF7,0xF7,0xE7,0xD5,0xF6,0xF7,0xF0,0xFF,0xFF,
						0xFF,0xFF,0x07,0xF7,0xF3,0xF7,0xB7,0xD7,0xD7,0xB7,0xF7,0xF3,0xF7,0x07,0xFF,0xFF
					};
				
/*******************************************************************************
* 函 数 名         :  main （主函数）
* 函数功能		   :  矩阵LED滚动显示
* 输    入         :  无
* 输    出         :  无
*******************************************************************************/
void main(void)
{
	INT8U i = 1 , mode = 1, count;
	_74HC595_Initialization();
	while(1)
	{
		if(mode == 1)
		{
			for(i = 1; i <= 16; i++)
			{
				MatrixLED(i, LED_duan1[i - 1], LED_duan1[i + 15]);
			}
		}
		else
		{
			for(i = 1; i <= 16; i++)
			{
				MatrixLED(i, LED_duan2[i - 1], LED_duan2[i + 15]);
			}
		}
		
		count++;
		if(count > 20)
		{
			count = 0;
			mode++;
			if(mode > 2)
				mode = 1;
		}
	}
}