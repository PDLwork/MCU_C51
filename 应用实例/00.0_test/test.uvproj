# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c LCD1602.c keyboard.c Timer.c Uart.c 74HC595.c STARTUP.A51 Delay.h keyboard.h LCD1602.h UserDef.h
